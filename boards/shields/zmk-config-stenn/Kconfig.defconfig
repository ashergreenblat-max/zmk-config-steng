## boards/shields/zmk-config-stenn/Kconfig.defconfig
```kconfig
if SHIELD_STENO

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "Steno"

endif
```
